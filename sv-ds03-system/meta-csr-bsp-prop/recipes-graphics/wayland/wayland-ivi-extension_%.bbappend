
SRC_URI += " \
           file://sv001-fix-screenshot-pixel-format.patch \
           file://sv002-fix-usage-of-eglGetDisplay.patch \
           file://sv003-discard-build-of-simple-ivi-share.patch \
         "
