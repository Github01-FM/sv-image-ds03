
RDEPENDS_${PN}_remove = "nativesdk-packagegroup-sdk-host"
